# Keil uVision project TK499_LTDC.uvprojx, settings and files
target TK499_LTDC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: TK499_LTDC +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..//@L.bin  ./obj/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: LV_CONF_INCLUDE_SIMPLE
  c include: ..\CMSIS_and_startup;..\CMSIS_and_startup\CMSIS;.\bsp;..\Hal_lib\inc;.\bsp\LCD;.\bsp\LED;.\bsp\SPI;.\bsp\sys;.\bsp\UART;.\bsp\Timer;.\bsp\exit;.\bsp\touch;.\bsp\TK499_I2C;.\lvgl;.\lvgl\src;.\lvgl\src\lv_core;.\lvgl\src\lv_draw;.\lvgl\src\lv_font;.\lvgl\src\lv_hal;.\lvgl\src\lv_misc;.\lvgl\src\lv_objx;.\lvgl\src\lv_themes;.\lvgl\porting;.\lv_examples;.\lvgl\src\lv_gpu;.\lv_examples\src\lv_demo_stress;..\project;.\lv_examples\src\lv_demo_printer;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x70020000 size 0x200000
  memory RVCT9: RAM 0x70220000 size 0x5dffff
  group startup
    ../CMSIS_and_startup/: startup_Tk499.s tk499.h sys.c
    ./: readme.txt
  group bsp
    ./bsp/: main.c lv_demo_widgets.c
    ./bsp/LCD/: LCD.c
    ./bsp/LED/: led.c
    ./bsp/SPI/: spi.c
    ./bsp/Timer/: timer.c
    ./bsp/UART/: UART.c
    ./bsp/touch/: touch_CTP.c
    ./bsp/TK499_I2C/: TK499_I2C.c
  group hal_lib
    ../Hal_lib/src/: HAL_gpio.c HAL_rcc.c HAL_tim.c HAL_exti.c HAL_misc.c HAL_uart.c HAL_spi.c HAL_dma.c HAL_i2c.c
  group lv_core
    ./lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lv_draw
    ./lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lv_font
    ./lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_eurostyle_14.c lv_font_eurostyle_16.c lv_font_eurostyle_bold_18.c lv_font_eurostyle_bold_50.c lv_font_eurostyle_bold_100.c lv_font_eurostyle_bold_extended_30.c lv_font_eurostyle_normal_12.c lv_font_eurostyle_normal_18.c lv_font_eurostyle_bold_26.c
  group lv_gpu
    ./lvgl/src/lv_gpu/: lv_gpu_stm32_dma2d.c
  group lv_hal
    ./lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ./lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lv_themes
    ./lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
  group lv_widgets
    ./lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group lv_porting
    ./lvgl/porting/: lv_port_disp.c lv_port_indev.c
    ./lvgl/: lv_conf.h lv_ex_conf.h
  group benchmark
    ./lv_examples/src/lv_demo_benchmark/: lv_demo_benchmark.c lv_demo_benchmark.h
  group example_assets
    ./lv_examples/src/assets/: img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_hand.c lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c img_cogwheel_indexed16.c img_cogwheel_rgb.c
  group printer
    ./lv_examples/src/lv_demo_printer/images/: lv_demo_printer_icon_bright.c lv_demo_printer_icon_eco.c lv_demo_printer_icon_hue.c lv_demo_printer_icon_pc.c lv_demo_printer_icon_tel.c lv_demo_printer_icon_wifi.c lv_demo_printer_img_btn_bg_1.c lv_demo_printer_img_btn_bg_2.c lv_demo_printer_img_btn_bg_3.c lv_demo_printer_img_btn_bg_4.c lv_demo_printer_img_cloud.c lv_demo_printer_img_copy.c lv_demo_printer_img_internet.c lv_demo_printer_img_mobile.c lv_demo_printer_img_no_internet.c lv_demo_printer_img_phone.c lv_demo_printer_img_print.c lv_demo_printer_img_printer2.c lv_demo_printer_img_ready.c lv_demo_printer_img_scan.c lv_demo_printer_img_scan_example.c lv_demo_printer_img_setup.c lv_demo_printer_img_usb.c lv_demo_printer_img_wave.c
    ./lv_examples/src/lv_demo_printer/: lv_demo_printer.c lv_demo_printer.h lv_demo_printer_theme.c lv_demo_printer_theme.h
  group user_interface
    ./bsp/: reflow_oven_theme.c reflow_oven_theme.h reflow_oven_ui.c reflow_oven_ui.h scifi_clock.c scifi_clock.h scifi_cont.c scifi_cont.h
    ./bsp/images/: down_96px.c icon_wifi.c light_active_64px.c light_inactive_64px.c power_36px.c switch_36px.c up_96px.c color_wheel_64px.c color_wheel_off_64px.c color_wheel_temp_64px.c
  group source
    ../FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group port
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
